Commit message: added init environment

File: models/paddle/paddle.urdf (robot description, URDF)
Before this commit: robot paddle, 1 links, 0 joints
Links:
- link paddle_link: geometry collision box size=0.009 0.075 0.05; collision cylinder length=0.01 radius=0.175
